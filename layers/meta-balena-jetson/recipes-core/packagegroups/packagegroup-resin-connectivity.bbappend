CONNECTIVITY_FIRMWARES_append = " tegra-firmware-brcm linux-firmware-iwlwifi-9000"
