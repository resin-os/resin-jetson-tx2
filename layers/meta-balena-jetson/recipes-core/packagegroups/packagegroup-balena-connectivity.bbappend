CONNECTIVITY_FIRMWARES_append = " tegra-firmware-brcm"
